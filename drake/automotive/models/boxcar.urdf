Commit message: The more asymmetric 'boxcar' is, the better for debugging.

File: drake/automotive/models/boxcar.urdf (robot description, URDF)
Before this commit: robot boxcar, 1 links, 0 joints
Links:
- link box_shape: geometry visual box size=2.0 1.5 1.0
